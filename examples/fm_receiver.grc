options:
  parameters:
    author: Signal Hound
    category: Custom
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: Fine Freq (MHz)
    start: '-.1'
    step: '.01'
    stop: '.1'
    value: freq - int(freq)
  states: {}
- name: tun_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: UHD Freq (MHz)
    start: '87.9'
    step: '0.1'
    stop: '108.1'
    value: freq/1e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 4
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_wfm_rcv
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    quad_rate: samp_rate
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/audio_decim)
  states: {}
- name: bb60_iq_0
  id: bb60_iq
  parameters:
    bandwidth: 200e3
    center: (tun_freq+fine)*1e6
    decimation: '64'
    purge: 'False'
    reflevel: '-20'
  states: {}
- name: blocks_multiply_const_vxx
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: 89.9e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: (tun_freq+fine)*1e6
    fftsize: '512'
    gui_hint: 2,0,2,4
    legend: 'False'
    name: ''
    showports: 'True'
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 625e3
  states: {}

connections:
- [analog_wfm_rcv, '0', blocks_multiply_const_vxx, '0']
- [bb60_iq_0, '0', analog_wfm_rcv, '0']
- [bb60_iq_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx, '0', audio_sink, '0']

metadata:
  file_format: 1
